# Repository cese-dci/dci2020b-charlieromano

## KiCad design driverDisplayLED/modulo_IR/modulo_IR.kicad_pcb

File driverDisplayLED/modulo_IR/README.md:

# Diseño de Circuitos Impresos

Trabajo práctico final

CESE 2020

**Autor**: Carlos German Carreño Romano

**Revisor**: Diego Brengi

| Fecha      | Versión | Descripción                          | Autor               |
| ---------- | ------- | ------------------------------------ | ------------------- |
| 2020-11-06 | 1.1     | Informe técnico del diseño propuesto | Carlos G. C. Romano |
|            |         |                                      |                     |

Parts:
C1, C2: 104; C_0504_1310Metric_Pad0.83x1.28mm_HandSolder
D1, D2: LED; LED_D1.8mm_W3.3mm_H2.4mm
H1, H2: MountingHole; Fiducial_1mm_Mask2mm
J1: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
R1, R2: 1K; R_0805_2012Metric
R3: 100; R_0805_2012Metric
R4, R5: 10K; R_0805_2012Metric
RV1: 20K; TRIM_3362P-1-103; PartNumber 3362P-203LF-ND
U1: SFH617A-1X001; SO-4_4.4x2.3mm_P1.27mm
U2: LM393; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C1.1, D1.2 (A), D2.2 (A), J1.1, R3.1, R4.1, R5.1, RV1.1
/D0: J1.2, R2.2, R5.2, U2.1
GND: C1.2, C2.2, J1.3, R1.2, RV1.3; also elsewhere on the board
unnamed 3: C2.1, R4.2, U2.3 (+); also elsewhere on the board
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed 6: R3.2; also elsewhere on the board
unnamed: RV1.2, U2.2 (-)

Notes on the sheet:
LED IR Tx
Circuito optoacoplador
LED IR Rx
Fiduciales

Board: 2 copper layers, 40.0 x 18.0 mm, 16 parts (0 on the bottom side), 8 nets.

Other parts of the board:
D3: LED; LED_D5.0mm_Horizontal_O3.81mm_Z3.0mm
D4: D_Photo; LED_D5.0mm_Horizontal_O3.81mm_Z3.0mm

Their connections:
GND: D3.1, D4.1; also elsewhere on the board
unnamed 3: D4.2; also elsewhere on the board
unnamed 6: D3.2; also elsewhere on the board

## KiCad design driverDisplayLED/driverDisplayLED.kicad_pcb

Board: 2 copper layers, 69 parts (0 on the bottom side), 95 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C11: C; C_0201_0603Metric
D1, D2: D; D_0201_0603Metric
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_2.7mm_M2.5_ISO14580
J1, J2, J3, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J16, J17: Conn_01x12_Male; PinSocket_1x12_P2.54mm_Vertical
J4: Conn_02x08_Counter_Clockwise; PinHeader_2x08_P2.54mm_Vertical
J19: Conn_01x02_Female; PhoenixContact_MCV_1,5_2-GF-3.5_1x02_P3.50mm_Vertical_Threa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
L1, L2, L3, L4, L5, L6, L7, L8: LedMatrix_M; 1588AB-24
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: FDS4953; SOIC127P600X175-8N
R1, R2, R3: R; R_0201_0603Metric
RN2: R_Network04; R_Array_SIP4
RN6, RN7, RN8, RN9: 50; R_Array_SIP4
U1, U4: 74HC245; SO-20-1EP_7.52x12.825mm_P1.27mm_EP6.045x12.09mm_Mask3.56x4.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
U2, U3, U7, U8: 74HC595; SO-16_5.3x10.2mm_P1.27mm
U5, U9: 74HC138D; SO-16_5.3x10.2mm_P1.27mm
U6, U10: 74HC04; TSSOP-14_4.4x5mm_P0.65mm

Connections:
/A1-SER: U1.3, U2.14
/A5-SRCLK: U1.7, U2.11, U3.11, U7.11, U8.11
/B0-b5: J4.10, U1.18
/B1-a5: J4.9, U1.17
/B2-b6: J4.12, U1.16
/B3-a6: J4.11, U1.15
/B4-b7: J4.14, U1.14
/B5B6B7-b8: J4.16, U1.11, U1.12, U1.13
/E1: U5.4, U10.4
/E3: U9.6, U10.6
/H1a: J1.12, J6.12, J10.12, J14.12, Q8.7, Q8.8
/H1b: J3.12, J8.12, J12.12, J16.12, Q7.7, Q7.8
/H2a: J1.11, J6.11, J10.11, J14.11, Q8.5, Q8.6, RN9.4
/H2b: J3.11, J8.11, J12.11, J16.11, Q7.5, Q7.6, RN8.4
/H3a: J1.10, J6.10, J10.10, J14.10, Q6.7, Q6.8, RN9.3
/H3b: J3.10, J8.10, J12.10, J16.10, Q5.7, Q5.8, RN8.3
/H4a: J1.9, J6.9, J10.9, J14.9, Q6.5, Q6.6, RN9.2
/H4b: J3.9, J8.9, J12.9, J16.9, Q5.5, Q5.6, RN8.2
/H5a: J2.9, J7.9, J11.9, J15.9, Q2.5, Q2.6, RN6.2
/H5b: J5.9, J9.9, J13.9, J17.9, Q1.5, Q1.6, RN7.2
/H6a: J2.10, J7.10, J11.10, J15.10, Q2.7, Q2.8, RN6.3
/H6b: J5.10, J9.10, J13.10, J17.10, Q1.7, Q1.8, RN7.3
/H7a: J2.11, J7.11, J11.11, J15.11, Q4.5, Q4.6, RN6.4
/H7b: J5.11, J9.11, J13.11, J17.11, Q3.5, Q3.6, RN7.4
/H8a: J2.12, J7.12, J11.12, J15.12, Q4.7, Q4.8
/H8b: J5.12, J9.12, J13.12, J17.12, Q3.7, Q3.8
/L1R1: J1.8, J3.8, U2.7
/L1R2: J1.7, J3.7, U2.6
/L1R3: J1.6, J3.6, U2.5
/L1R4: J1.5, J3.5, U2.4
/L1R5: J1.4, J3.4, U2.3
/L1R6: J1.3, J3.3, U2.2
/L1R7: J1.2, J3.2, U2.1
/L1R8: J1.1, J3.1, U2.15
/L3R1: J6.8, J8.8, U3.7
/L3R2: J6.7, J8.7, U3.6
/L3R3: J6.6, J8.6, U3.5
/L3R4: J6.5, J8.5, U3.4
/L3R5: J6.4, J8.4, U3.3
/L3R6: J6.3, J8.3, U3.2
/L3R7: J6.2, J8.2, U3.1
/L3R8: J6.1, J8.1, U3.15
/L5R1: J10.8, J12.8, U7.7
/L5R2: J10.7, J12.7, U7.6
/L5R3: J10.6, J12.6, U7.5
/L5R4: J10.5, J12.5, U7.4
/L5R5: J10.4, J12.4, U7.3
/L5R6: J10.3, J12.3, U7.2
/L5R7: J10.2, J12.2, U7.1
/L5R8: J10.1, J12.1, U7.15
/L7R1: J14.8, J16.8, U8.7
/L7R2: J14.7, J16.7, U8.6
/L7R3: J14.6, J16.6, U8.5
/L7R4: J14.5, J16.5, U8.4
/L7R5: J14.4, J16.4, U8.3
/L7R6: J14.3, J16.3, U8.2
/L7R7: J14.2, J16.2, U8.1
/L7R8: J14.1, J16.1, U8.15
/RCLK: U2.12, U3.12, U7.12, U8.12
/Y0-G2a: Q2.4, U9.15
/Y0-G2b: Q1.4, U5.15
/Y1-G1a: Q2.2, U9.14
/Y1-G1b: Q1.2, U5.14
/Y2-G2a: Q4.4, U9.13
/Y2-G2b: Q3.4, U5.13
/Y3-G1a: Q4.2, U9.12
/Y3-G1b: Q3.2, U5.12
/Y4-G2a: Q6.4, U9.11
/Y4-G2b: Q5.4, U5.11
/Y5-G1a: Q6.2, U9.10
/Y5-G1b: Q5.2, U5.10
/Y6-G2a: Q8.4, U9.9
/Y6-G2b: Q7.4, U5.9
/Y7-G1a: Q8.2, U9.7
/Y7-G1b: Q7.2, U5.7
/a4-A5: J4.7, U4.7
GND: C1.1, C2.1, C3.1, C4.1, C6.2, C7.1, C8.1, C11.2, D1.2, J4.1, J4.3, J4.5, J4.15, J5.1, J5.2, J5.3, J5.4, J5.5, J5.6, J5.7, J5.8, J9.1, J9.2, J9.3, J9.4, J9.5, J9.6, J9.7, J9.8, J13.1, J13.2, J13.3, J13.4, J13.5, J13.6, J13.7, J13.8, J17.1, J17.2, J17.3, J17.4, J17.5, J17.6, J17.7, J17.8, J19.1, R2.2, R3.2, RN2.1, RN6.1, RN7.1, RN8.1, RN9.1, U1.1, U1.10, U1.19, U2.8, U2.13, U3.8, U3.13, U4.10, U5.8, U6.7, U7.8, U7.13, U8.8, U8.13, U9.8
unnamed: C5.1, U10.2
unnamed: C5.2, D1.1, D2.2
unnamed: C6.1, D2.1, R3.1, U10.3
unnamed: J4.2, R1.2, U4.3
unnamed: J4.4, U4.4
unnamed: J4.6, U4.5
unnamed: J4.8, U4.6
unnamed: R1.1, R2.1, U10.1
unnamed: RN2.2, U1.8
unnamed: U2.9, U3.14
unnamed: U3.9, U7.14
unnamed: U4.13, U5.5, U9.5
unnamed: U4.14, U5.6, U9.4
unnamed: U4.15, U5.3, U9.3
unnamed: U4.16, U5.2, U9.2
unnamed: U4.17, U5.1, U9.1
unnamed: U7.9, U8.14
VCC: C1.2, C2.2, C3.2, C4.2, C7.2, C8.2, C11.1, J19.2, Q1.1, Q1.3, Q2.1, Q2.3, Q3.1, Q3.3, Q4.1, Q4.3, Q5.1, Q5.3, Q6.1, Q6.3, Q7.1, Q7.3, Q8.1, Q8.3, U1.20, U2.10, U2.16, U3.10, U3.16, U4.1, U4.2, U4.20, U5.16, U6.14, U7.10, U7.16, U8.10, U8.16, U9.16

## Commit log

2020-09-18 Bosquejo inicial del esquemático
2020-09-19 set: 74HC245D - CONN2X8 - 74HC245D - 74HC138D
2020-09-20 primer bloque 74HC595D: shift-register
2020-09-20 segundo bloque 74HC595D: shift-register
2020-09-20 bloque inverters, bloque mosfets. Pendiente: añadir segunda hoja a derecha, conectar matrices, completar 74HC245D(1), revisar los NC.
2020-09-26 netlist, asociación de componentes
2020-09-26 cambio conector 2x08 J4
2020-09-26 agrego borde PCB de muestra, y sus cotas
2020-09-30 agrego modulo myLedMatrix. Probar instanciar debido al path local
2020-10-01 new LedMatrix_M + array 4953 update + G1-G8 paralelo
2020-10-02 Conecto las matrices LED
2020-10-02 place components into PCB
2020-10-03 place components, continued
2020-10-07 ERC with no errors. Onlly warnings
2020-10-07 agrego textos. Listo para revisión esquemático
2020-10-10 place and route
2020-10-10 routing and mountholders
2020-10-11 footprint matrix + vias primer bloque
2020-10-17 Esquemático actualizado, encapsulados de capacitores actualizados, footprints de prueba de las matrices led, vias
2020-10-17 place and route++
2020-10-25 Cambio a formato jerárquico
2020-10-26 Agrego codigos de catalogo, documentación, y linkeo del borrador del PCB
2020-10-26 Actualizo README
2020-10-26 muevo archivos de version sin jerarquía de hojas
2020-10-29 corrijo conexión de pin7 U1
2020-11-02 Agrego nuevo proyecto: Modulo Infrarrojo TxRx
2020-11-06 Correcciones basadas en la revisión del esquemático.
2020-11-06 Part numbers.
2020-11-06 asignacion de componentes
2020-11-06 placing components
2020-11-06 Diseño del PCB
2020-11-06 Agrego informe versión borrador
2020-11-06 uplad del borrador del informe
2020-11-07 Ordeno el repo y actualizo esquemático y netlist
2020-11-07 rediseño PCB
2020-11-08 actualizo correcciones PCB, con DRC sin errores, margenes actualizdos, mounting hole y fiducial, labels, y planos de Vcc y GND
2020-11-08 actualizo rotulo
2020-11-08 agrego notas de fabricacion
2020-11-08 agrego cotas, modelo 3d del trimmer, refill de planos
2020-11-08 reorganizo repo, actualizo imagenes

Notices in the files:
driverDisplayLED/modulo_IR/modulo_IR.kicad_pcb:
GPL License
